# IAR project Project.ewp, settings and files
configuration STM32H747I-DISCO_FoodReco_Float_Ext (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; ARM_MATH_CM7; __FPU_PRESENT=1; DATA_IN_ExtSDRAM; STM32IPL; MEMORY_SCHEME=1; CAMERA_CAPTURE_RES=1; PIXEL_FMT_CONV=1
  ICCARM.CCIncludePath2: ..\CM7\Inc; ..\..\..\Common\CM7\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H747I-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\ov9655; ..\..\..\..\..\..\Drivers\BSP\Components\otm8009a; ..\..\..\..\..\..\Drivers\BSP\Components\mt25tl01g; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Utilities\lcd; ..\..\..\..\..\..\Middlewares\ST\STM32_AI_Runtime\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_AI_Utilities\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_ImageProcessing_Library\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Full_External.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I-DISCO_FoodReco_Float_Split (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; ARM_MATH_CM7; __FPU_PRESENT=1; DATA_IN_ExtSDRAM; STM32IPL; MEMORY_SCHEME=2; CAMERA_CAPTURE_RES=1; PIXEL_FMT_CONV=1
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Split.icf
configuration STM32H747I-DISCO_FoodReco_Float_Ext_Qspi (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; ARM_MATH_CM7; __FPU_PRESENT=1; DATA_IN_ExtSDRAM; STM32IPL; MEMORY_SCHEME=1; CAMERA_CAPTURE_RES=1; PIXEL_FMT_CONV=1; WEIGHT_QSPI=1; WEIGHT_QSPI_PROGED=0; WEIGHT_EXEC_EXTRAM=0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Full_External_Qspi.icf
configuration STM32H747I-DISCO_FoodReco_Float_Split_Qspi (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; ARM_MATH_CM7; __FPU_PRESENT=1; DATA_IN_ExtSDRAM; STM32IPL; MEMORY_SCHEME=2; CAMERA_CAPTURE_RES=1; PIXEL_FMT_CONV=1; WEIGHT_QSPI=1; WEIGHT_QSPI_PROGED=0; WEIGHT_EXEC_EXTRAM=0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Split_Qspi.icf
configuration STM32H747I-DISCO_FoodReco_Float_Ext_Sdram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; ARM_MATH_CM7; __FPU_PRESENT=1; DATA_IN_ExtSDRAM; STM32IPL; MEMORY_SCHEME=1; CAMERA_CAPTURE_RES=1; PIXEL_FMT_CONV=1; WEIGHT_QSPI=1; WEIGHT_QSPI_PROGED=0; WEIGHT_EXEC_EXTRAM=1
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Full_External_Qspi.icf
configuration STM32H747I-DISCO_FoodReco_Float_Split_Sdram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; ARM_MATH_CM7; __FPU_PRESENT=1; DATA_IN_ExtSDRAM; STM32IPL; MEMORY_SCHEME=2; CAMERA_CAPTURE_RES=1; PIXEL_FMT_CONV=1; WEIGHT_QSPI=1; WEIGHT_QSPI_PROGED=0; WEIGHT_EXEC_EXTRAM=1
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Split_Qspi.icf
  group Application/CM7
    ../../../Common/CM7/Src/: ai_interface.c fp_vision_ai.c fp_vision_camera.c fp_vision_display.c fp_vision_preproc.c fp_vision_test.c fp_vision_utils.c sd_diskio.c
    ../CM7/Src/: fp_vision_app.c main.c network.c network_data.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/Common
    ../Common/Src/: system_stm32h7xx.c
  group Application/EWARM
    ./: startup_cm4.s startup_stm32h747xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../../Drivers/BSP/Components/ov9655/: ov9655.c ov9655_reg.c
  group Drivers/BSP/STM32H747I_Discovery
    ../../../../../../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery.c stm32h747i_discovery_bus.c stm32h747i_discovery_camera.c stm32h747i_discovery_lcd.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sd.c stm32h747i_discovery_sdram.c
  group Drivers/STM32H7xx_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/STM32_AI_Runtime
    ../../../../../../Middlewares/ST/STM32_AI_Runtime/lib/: NetworkRuntime710_CM7_IAR.a
  group Middlewares/STM32_AI_Utilities
    ../../../../../../Middlewares/ST/STM32_AI_Utilities/Src/: ai_utilities.c
  group Middlewares/STM32_ImageProcessing_Library
    ../../../../../../Middlewares/ST/STM32_ImageProcessing_Library/Src/: imlib.c stm32ipl.c stm32ipl_convert.c stm32ipl_image_io.c stm32ipl_mem_alloc.c stm32ipl_resize.c umm_malloc.c
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
