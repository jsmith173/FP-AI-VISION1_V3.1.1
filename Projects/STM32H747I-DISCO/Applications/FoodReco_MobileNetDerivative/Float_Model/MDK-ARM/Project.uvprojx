# Keil uVision project Project.uvprojx, settings and files
target STM32H747I-DISCO_FoodReco_Float_Ext (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_DISCO,CORE_CM7,ARM_MATH_CM7,__FPU_PRESENT=1,DATA_IN_ExtSDRAM,STM32IPL,MEMORY_SCHEME=1,CAMERA_CAPTURE_RES=1,PIXEL_FMT_CONV=1
  c include: ../CM7/Inc;../../../Common/CM7/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/DSP/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H747I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/ov9655;../../../../../../Drivers/BSP/Components/otm8009a;../../../../../../Drivers/BSP/Components/mt25tl01g;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/lcd;../../../../../../Middlewares/ST/STM32_AI_Runtime/Inc;../../../../../../Middlewares/ST/STM32_AI_Utilities/Inc;../../../../../../Middlewares/ST/STM32_ImageProcessing_Library/Inc;../../../../../../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h7xx_CM7_FLASH_Full_External.sct
  group Application/CM7
    ../../../Common/CM7/Src/: ai_interface.c fp_vision_ai.c fp_vision_camera.c fp_vision_display.c fp_vision_preproc.c fp_vision_test.c fp_vision_utils.c sd_diskio.c
    ../CM7/Src/: fp_vision_app.c main.c network.c network_data.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/Common
    ../Common/Src/: system_stm32h7xx.c
  group Application/MDK-ARM
    ./: startup_stm32h747xx_CM7.s
    ./: startup_stm32h747xx_CM4.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../../Drivers/BSP/Components/ov9655/: ov9655.c ov9655_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/STM32H747I_Discovery
    ../../../../../../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery.c stm32h747i_discovery_bus.c stm32h747i_discovery_camera.c stm32h747i_discovery_lcd.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sd.c stm32h747i_discovery_sdram.c
  group Drivers/STM32H7xx_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/STM32_AI_Runtime
    ../../../../../../Middlewares/ST/STM32_AI_Runtime/lib/: NetworkRuntime710_CM7_Keil.lib
  group Middlewares/STM32_AI_Utilities
    ../../../../../../Middlewares/ST/STM32_AI_Utilities/Src/: ai_utilities.c
  group Middlewares/STM32_ImageProcessing_Library
    ../../../../../../Middlewares/ST/STM32_ImageProcessing_Library/Src/: array.c fmath.c imlib.c rectangle.c stm32ipl.c stm32ipl_convert.c stm32ipl_image_io.c stm32ipl_mem_alloc.c stm32ipl_rect.c stm32ipl_resize.c umm_malloc.c xyz_tab.c
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
target STM32H747I-DISCO_FoodReco_Float_Split (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: Project
  c flags: as above
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_DISCO,CORE_CM7,ARM_MATH_CM7,__FPU_PRESENT=1,DATA_IN_ExtSDRAM,STM32IPL,MEMORY_SCHEME=2,CAMERA_CAPTURE_RES=1,PIXEL_FMT_CONV=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h7xx_CM7_FLASH_Split.sct
target STM32H747I-DISCO_FoodReco_Float_Ext_Qspi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: Project
  c flags: as above
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_DISCO,CORE_CM7,ARM_MATH_CM7,__FPU_PRESENT=1,DATA_IN_ExtSDRAM,STM32IPL,MEMORY_SCHEME=1,CAMERA_CAPTURE_RES=1,PIXEL_FMT_CONV=1,WEIGHT_QSPI=1,WEIGHT_QSPI_PROGED=0,WEIGHT_EXEC_EXTRAM=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h7xx_CM7_FLASH_Full_External_Qspi.sct
target STM32H747I-DISCO_FoodReco_Float_Split_Qspi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: Project
  c flags: as above
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_DISCO,CORE_CM7,ARM_MATH_CM7,__FPU_PRESENT=1,DATA_IN_ExtSDRAM,STM32IPL,MEMORY_SCHEME=2,CAMERA_CAPTURE_RES=1,PIXEL_FMT_CONV=1,WEIGHT_QSPI=1,WEIGHT_QSPI_PROGED=0,WEIGHT_EXEC_EXTRAM=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h7xx_CM7_FLASH_Split_Qspi.sct
target STM32H747I-DISCO_FoodReco_Float_Ext_Sdram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: Project
  c flags: as above
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_DISCO,CORE_CM7,ARM_MATH_CM7,__FPU_PRESENT=1,DATA_IN_ExtSDRAM,STM32IPL,MEMORY_SCHEME=1,CAMERA_CAPTURE_RES=1,PIXEL_FMT_CONV=1,WEIGHT_QSPI=1,WEIGHT_QSPI_PROGED=0,WEIGHT_EXEC_EXTRAM=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h7xx_CM7_FLASH_Full_External_Qspi.sct
target STM32H747I-DISCO_FoodReco_Float_Split_Sdram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: Project
  c flags: as above
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_DISCO,CORE_CM7,ARM_MATH_CM7,__FPU_PRESENT=1,DATA_IN_ExtSDRAM,STM32IPL,MEMORY_SCHEME=2,CAMERA_CAPTURE_RES=1,PIXEL_FMT_CONV=1,WEIGHT_QSPI=1,WEIGHT_QSPI_PROGED=0,WEIGHT_EXEC_EXTRAM=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h7xx_CM7_FLASH_Split_Qspi.sct
software components: CMSIS:CORE 4.3.0
